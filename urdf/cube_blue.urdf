Commit message: Modify the gripper control method and update the cube’s URDF model file

File: urdf/cube_blue.urdf (robot description, URDF)
Before this commit: robot blue_rectangular_prism, 1 links, 0 joints
Links:
- link baseLink: mass 0.5 -> 0.08
